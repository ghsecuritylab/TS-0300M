# Keil uVision project TS-0300.uvprojx, settings and files
target TS-0300 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MIMXRT1062CVL5A NXP
  pack: NXP.MIMXRT1062_DFP.11.0.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x00000000,0x020000) XRAM(0x20200000,0x0c0000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: TS-0300 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG,USB_STACK_FREERTOS,XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, CPU_MIMXRT1062DVL6A, FSL_RTOS_FREE_RTOS, ARM_MATH_CM7,FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE, USE_RTOS=1,HTTPSRV_CFG_WEBSOCKET_ENABLED=1, FSL_RTOS_FREE_RTOS,SDK_I2C_BASED_COMPONENT_USED=1
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ..\_project;..\xip;..\app;..\api;..\api\utilities;..\api\components;..\api\components\codec;..\api\components\lists;..\api\components\serial_manager;..\api\components\uart;..\amazon-freertos;..\amazon-freertos\lib\include;..\amazon-freertos\lib\include\private;..\amazon-freertos\lib\FreeRTOS\portable\RVDS\ARM_CM4F;..\CMSIS\Include;..\hal;..\drivers\sdk;..\drivers\peripheral;..\drivers\peripheral\net-phy;..\drivers\peripheral\dsp;..\drivers\startup;..\log;..\usb;..\usb\api;..\usb\host;..\usb\host\class;..\usb\include;..\usb\osa;..\usb\phy;..\usb\templates\config;..\fatfs;..\fatfs\fsl_usb_disk;..\lwip;..\lwip\opt;..\lwip\port;..\lwip\src;..\lwip\src\include;..\lwip\src\include\lwip\apps;..\lwip\src\apps\httpsrv;..\lwip\contrib\apps\udpecho
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ..\_project;..\startup;..\..\TS-0300_V1.0
  library: MicroLIB
  memory RVCT6: RAM 0x20200000 size 0xc0000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\MIMXRT1062xxxxx_flexspi_nor.scf
  link misc: --remove 
--keep=*(.boot_hdr.ivt) 
--keep=*(.boot_hdr.boot_data) 
--keep=*(.boot_hdr.dcd_data) 
--keep=*(.boot_hdr.conf) 
--predefine="-DXIP_BOOT_HEADER_ENABLE=1"
  group application
    ../app/: app.c app.h global_config.h model_version.c model_version.h conference.c conference.h wired_unit.c wired_unit.h wifi_unit.c wifi_unit.h external_ctrl.c external_ctrl.h protocol.c protocol.h screen.c screen.h database.c database.h camera.c camera.h
  group api
    ../api/: network.c network.h ram.c ram.h usb_disk.c usb_disk.h audio.c audio.h time.c time.h dsp.c dsp.h
  group api-utilities
    ../api/utilities/: data_queue.c data_queue.h data_stream.c data_stream.h fsl_assert.c fsl_notifier.c fsl_notifier.h fsl_str.c fsl_str.h usb_device_config.h fsl_debug_console.c
  group api-components
    ../api/components/codec/: fsl_codec_common.c fsl_codec_common.h
    ../api/components/lists/: generic_list.c generic_list.h
    ../api/components/serial_manager/: serial_manager.c serial_port_uart.c
  group os-config
    ../amazon-freertos/: FreeRTOSConfig.h LICENSE
  group os-amazon-freertos
    ../amazon-freertos/lib/FreeRTOS/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../amazon-freertos/lib/FreeRTOS/portable/MemMang/: heap_4.c
    ../amazon-freertos/lib/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c portmacro.h fsl_tickless_generic.h fsl_tickless_systick.c
  group os-amazon-freertos-inc
    ../amazon-freertos/lib/include/: event_groups.h FreeRTOS.h freertos_tasks_c_additions.h message_buffer.h queue.h semphr.h stream_buffer.h task.h timers.h
    ../amazon-freertos/lib/include/private/: mpu_wrappers.h portable.h projdefs.h stack_macros.h
  group hal
    ../hal/: hal.c hal.h hal_phy.c hal_phy.h hal_sai.c hal_sai.h hal_rtc.c hal_rtc.h hal_eeprom.c hal_eeprom.h hal_gpio.c hal_gpio.h hal_mac_phy.c hal_mac_phy.h hal_uart.c hal_uart.h hal_aud_codec.c hal_aud_codec.h hal_spi_flash.c hal_spi_flash.h
  group drivers-peripheral
    ../drivers/peripheral/: drivers_common.c drivers_common.h
    ../drivers/peripheral/net-phy/: ksz8081.c ksz8081.h lan8720.c lan8720.h rtl8306m.c rtl8306m.h dm9051.c dm9051.h
    ../drivers/peripheral/rtc/: pcf8563.c pcf8563.h
    ../drivers/peripheral/eeprom/: at24c512.c at24c512.h
    ../drivers/peripheral/mp3/: wt2000a.c wt2000a.h
    ../drivers/peripheral/aud-codec/: nau88c22.c nau88c22.h
    ../drivers/peripheral/flash/: w25qxx.c w25qxx.h
    ../drivers/peripheral/dsp/: i2c_adau1466.c i2c_adau1466.h
  group drivers-sdk
    ../drivers/sdk/: board.c board.h clock_config.c clock_config.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_dmamux.c fsl_dmamux.h fsl_edma.c fsl_edma.h fsl_enet.c fsl_enet.h fsl_flexram.c fsl_flexram.h fsl_gpio.c fsl_gpio.h fsl_lpi2c.c fsl_lpi2c.h fsl_lpuart.c fsl_lpuart.h fsl_pit.c fsl_pit.h fsl_sai.c fsl_sai.h fsl_sai_edma.c fsl_sai_edma.h pin_mux.c pin_mux.h fsl_lpspi.c fsl_lpspi.h
  group log
    ../log/: debug.c debug.h
  group startup
    ../drivers/startup/: fsl_device_registers.h MIMXRT1062_features.h startup_MIMXRT1062.s system_MIMXRT1062.c system_MIMXRT1062.h MIMXRT1062.h
  group xip
    ../xip/: evkmimxrt1060_flexspi_nor_config.c evkmimxrt1060_flexspi_nor_config.h evkmimxrt1060_sdram_ini_dcd.c evkmimxrt1060_sdram_ini_dcd.h fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
  group usb-api
    ../usb/api/: host_msd_fatfs.c host_msd_fatfs.h
  group usb-host
    ../usb/host/: usb_host.h usb_host_devices.c usb_host_devices.h usb_host_ehci.c usb_host_ehci.h usb_host_framework.c usb_host_framework.h usb_host_hci.c usb_host_hci.h
  group usb-host-class
    ../usb/host/class/: usb_host_hub.c usb_host_hub.h usb_host_hub_app.c usb_host_hub_app.h usb_host_msd.c usb_host_msd.h usb_host_msd_ufi.c
  group usb-include
    ../usb/include/: usb.h usb_misc.h usb_spec.h
  group usb-osa
    ../usb/osa/: usb_osa.h usb_osa_freertos.c usb_osa_freertos.h
  group usb-phy
    ../usb/phy/: usb_phy.c usb_phy.h
  group fatfs
    ../fatfs/: diskio.c diskio.h ff.c ff.h ffconf.h ffsystem.c ffunicode.c
  group fatfs-usb
    ../fatfs/fsl_usb_disk/: fsl_usb_disk_freertos.c fsl_usb_disk.h
  group lwip-contrib-apps-udpecho
    ../lwip/contrib/apps/udpecho/: udpecho.c udpecho.h
  group lwip-opt
    ../lwip/opt/: lwipopts.h
  group lwip-src-apps-mdns
    ../lwip/src/apps/mdns/: mdns.c
  group lwip-src-apps-httpsrv
    ../lwip/src/apps/httpsrv/: httpsrv.c httpsrv.h httpsrv_base64.c httpsrv_base64.h httpsrv_config.h httpsrv_fs.c httpsrv_fs.h httpsrv_fs_data.c httpsrv_port.h httpsrv_prv.h httpsrv_script.c httpsrv_script.h httpsrv_sha1.c httpsrv_sha1.h httpsrv_supp.c httpsrv_supp.h httpsrv_task.c httpsrv_tls.c httpsrv_tls.h httpsrv_utf8.c httpsrv_utf8.h httpsrv_ws.c httpsrv_ws.h httpsrv_ws_api.c httpsrv_ws_prv.h
  group lwip-src-include-lwip-apps
    ../lwip/src/include/lwip/apps/: mdns.h mdns_priv.h mqtt_opts.h
  group lwip-src-api
    ../lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwip-src-core
    ../lwip/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group lwip-src-core-ipv4
    ../lwip/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group lwip-src-core-ipv6
    ../lwip/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
  group lwip-src-include-lwip
    ../lwip/src/include/lwip/: api.h arch.h autoip.h debug.h def.h dhcp.h dhcp6.h dns.h err.h errno.h etharp.h ethip6.h icmp.h icmp6.h igmp.h inet.h inet_chksum.h init.h ip.h ip_addr.h ip4.h ip4_addr.h ip4_frag.h ip6.h ip6_addr.h ip6_frag.h mem.h memp.h mld6.h nd6.h netbuf.h netdb.h netif.h netifapi.h opt.h pbuf.h raw.h sio.h snmp.h sockets.h stats.h sys.h tcp.h tcpip.h timeouts.h udp.h
  group lwip-src-include-lwip-priv
    ../lwip/src/include/lwip/priv/: api_msg.h memp_priv.h memp_std.h nd6_priv.h tcp_priv.h tcpip_priv.h
  group lwip-src-include-lwip-prot
    ../lwip/src/include/lwip/prot/: autoip.h dhcp.h dns.h etharp.h ethernet.h icmp.h icmp6.h igmp.h ip.h ip4.h ip6.h mld6.h nd6.h tcp.h udp.h
  group lwip-src-include-netif
    ../lwip/src/include/netif/: etharp.h ethernet.h lowpan6.h lowpan6_opts.h slipif.h
  group lwip-src-include-netif-ppp
    ../lwip/src/include/netif/ppp/: ccp.h chap_ms.h chap-md5.h chap-new.h eap.h ecp.h eui64.h fsm.h ipcp.h ipv6cp.h lcp.h magic.h mppe.h ppp.h ppp_impl.h ppp_opts.h pppapi.h pppcrypt.h pppdebug.h pppoe.h pppol2tp.h pppos.h upap.h vj.h
  group lwip-src-include-netif-ppp-polarssl
    ../lwip/src/include/netif/ppp/polarssl/: arc4.h des.h md4.h md5.h sha1.h
  group lwip-src-include-posix
    ../lwip/src/include/posix/: errno.h netdb.h
  group lwip-src-include-posix-sys
    ../lwip/src/include/posix/sys/: socket.h
  group lwip-src-netif
    ../lwip/src/netif/: ethernet.c lowpan6.c slipif.c
  group lwip-src-netif-ppp
    ../lwip/src/netif/ppp/: auth.c ccp.c chap_ms.c chap-md5.c chap-new.c demand.c eap.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c lwip_ecp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c
  group lwip-port
    ../lwip/port/: ethernetif.c ethernetif.h sys_arch.c
  group lwip-port-arch
    ../lwip/port/arch/: cc.h perf.h sys_arch.h
  group doc
    ../doc/: readme.txt VersionDescription.txt
